Commit message: Add self-collision checks to APF-RRT planner

File: src/rm65_description/urdf/rm_65_6f_description.urdf (robot description, URDF)
Before this commit: robot rm65, 7 links, 6 joints
Joints:
- added joint world_joint: type fixed, parent world, child base_link
